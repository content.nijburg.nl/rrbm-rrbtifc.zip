Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: ee58df14-0892-46dd-90a7-e70538a9e90b, NumberOfSaves: 30]
File name: Project Number
Time: 2024-01-17T13:37:38+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, OutPort_1629115_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_swirl diffuser rrbm-rrbt LT_sacs:350, NLRS_57_AIR_UN_swirl diffuser rrbm-rrbt LT_sacs:350:1629115
In: Default
Type - Description: Modular Swirl return grill, Type RRBM and RRBT; PredefinedType: DIFFUSER; Material: RAL9010, Sendzimir verzinkt
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_swirl diffuser rrbm-rrbt LT_sacs; SACS_Base_Index: 2
Type - Constraints - Default Elevation: 0 mm
Type - General - Lookup_Grill_Factors: Grill_Selection_Factors; SACS_Article_Data: RRBM-RRBT_Data; SACS_Revised_ by: J. Feeke; SACS_Revision_Date: 04-04-2022; SACS_Revision_Number: 3.19.02
Type - Identity Data - Assembly Code: 57.00; Cost: 0; Description: Modular Swirl return grill, Type RRBM and RRBT; Manufacturer: Solid Air Climate Solutions; Model: RRBM and RRBT; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 04-04-2022; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.19.02; NLRS_C_description: Modular Swirl return grill, Type RRBM and RRBT; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Comments: Please make sure flow is set to m3/h!; Type Name: 350; URL: https://solid-air.nl/producten/solid-air-wervelrooster-rtbm-rrbm/
Type - Mechanical - Flow - Max Flow: 125 dm3/s; Min Flow: 30 dm3/s
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Solutions
Classification: 57.00 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: 350; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_swirl diffuser rrbm-rrbt LT_sacs; Family and Type: NLRS_57_AIR_UN_swirl diffuser rrbm-rrbt LT_sacs: 350; Type: 350; Type Id: 1629083
Model Properties - SACS_Color_Ral: yes; SACS_Connector_Top: no; SACS_Lined_Plenum: no; SACS_Low_Plenum: no; SACS_Option_1: RRBM; SACS_Option_2: OU OC; SACS_Oval_Connector: yes; SACS_Standard_Color: yes; SACS_Sunken_Face: no
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - NLRS_M_c01_diameter: 160 mm; SACS_Plenum_Height: 185 mm; Volume: 0.000818313 m3
Identity Data - Mark: 7011; NLRS_C_materiaal_kleur: Ral 9010; NLRS_C_model: RRBMOU 350 OV; SACS_Article_Code: NB; SACS_Gross_Cost: 196; SACS_Price_Date: 01-02-2022
Materials and Finishes - SACS_Color: Ral 9010; SACS_Face_Color: RAL9010; SACS_Lining_Thickness: 0 mm
Mechanical - NLRS_M_c01_drukverlies_statisch: 55.8 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 35 Pa; System Classification: Return Air
Mechanical - Flow - Flow: 138.889 dm3/s; NLRS_M_c01_debiet: 138.889 dm3/s; SACS_Lp_dBA: 39
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Flow out of default specification!; SACS_Warning_Text_Ploss: Pressure loss over requested boundary!; SACS_Warning_Text_Sound: Sound production over requested boundary!
Visibility - SACS_Arrows_and_Throw_Enabled: yes; SACS_Warning_Disable: no
